# Keil uVision project EasyOS.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8G1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: EasyOS +hex
  c flags: Optimize=1 SizeSpeed=1
  c include: C:\DevTool\Keil_v5\C51\INC\**;.\CODE\APP;.\CODE\BSP;.\CODE\EXT-LIB;.\CODE\OS
  asm include: C:\DevelopTool\Keil_v5\C51\INC\**;.\CODE\APP;.\CODE\BSP;.\CODE\EXT-LIB;.\CODE\OS
  link misc: REMOVEUNUSED
  group APP
    ./CODE/APP/: STARTUP.A51 cfg.h main.c
  group BSP
    ./CODE/BSP/: bsp.c bsp.h bsp_uart.c bsp_uart.h
  group EXT-LIB
    ./CODE/EXT-LIB/: lib_delay.c lib_delay.h lib_stdint.h lib_mem.c lib_mem.h
  group OS
    ./CODE/OS/: os.c os.h os_timer.c os_timer.h os_core.asm
